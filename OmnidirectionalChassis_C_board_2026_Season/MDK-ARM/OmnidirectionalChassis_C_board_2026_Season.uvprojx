# Keil uVision project OmnidirectionalChassis_C_board_2026_Season.uvprojx, settings and files
target OmnidirectionalChassis_C_board_2026_Season (6220000::V6.22::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: OmnidirectionalChassis_C_board_2026_Season +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./User
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group User/High/Collectivity
    ./User/High/Collectivity/: Ensemble.cpp Ensemble.hpp
  group User\High\Task
    ./User/High/Task/: TaskProcess.cpp TaskProcess.hpp
  group User\Middle\Communication
    ./User/Middle/Communication/: BoardCommunication_CtoA.cpp BoardCommunication_CtoA.hpp
  group User\Middle\MotorControl
    ./User/Middle/MotorControl/: ADRC.cpp ADRC.hpp Feedback.cpp Feedback.hpp PID.cpp PID.hpp Invoke.cpp Invoke.hpp
  group User\Middle\RemoteControl
    ./User/Middle/RemoteControl/: RemoteOperation.cpp RemoteOperation.hpp
  group User\Low\ControllerAreaNetwork
    ./User/Low/ControllerAreaNetwork/: UserCan.cpp UserCan.hpp
  group User\Low\MotorLibrary
    ./User/Low/MotorLibrary/: BenMo.cpp BenMo.hpp DaMiao.cpp DaMiao.hpp DJIMotor.cpp DJIMotor.hpp LingKongMortor.cpp LingKongMotor.hpp
  group User\Low\UniversalAsynchronousTransceiver
    ./User/Low/UniversalAsynchronousTransceiver/: Clicker.cpp Clicker.hpp SerialCallback.cpp SerialCallback.hpp
  group User\Middle\Buzzer
    ./User/Middle/Buzzer/: buzzer.cpp buzzer.hpp
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.15.0
